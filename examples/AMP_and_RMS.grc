options:
  parameters:
    generate_options: qt_gui
    id: AMP_and_RMS
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: unina_my_amplifier_0
  id: unina_my_amplifier
  parameters:
    gain: '2.0'
  states: {}
- name: unina_rms_voltmeter_0
  id: unina_rms_voltmeter
  parameters:
    vlen: '1024'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', unina_my_amplifier_0, '0']
- [unina_my_amplifier_0, '0', unina_rms_voltmeter_0, '0']
- [unina_rms_voltmeter_0, '0', qtgui_number_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
